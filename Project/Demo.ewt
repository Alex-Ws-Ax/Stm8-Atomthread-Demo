<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App\System.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\Uart.c</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <group>
      <name>Device</name>
      <file>
        <name>$PROJ_DIR$\..\Device\Beep\Beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Device\RC522\RC522.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Driver\Spi.c</name>
    </file>
  </group>
  <group>
    <name>FwLib</name>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_irtim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_wfe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FwLib\src\stm8l15x_wwdg.c</name>
    </file>
  </group>
</project>


